# Keil uVision project MiniRemoter.uvprojx, settings and files
target MiniRemoter (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MiniRemoter +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c misc: --locale=english
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\COMMON\interface;..\TASK\interface;..\CONFIG\interface;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\GUI_APP\interface;..\GUI_DRV\interface;..\HARDWARE\interface;..\RTT;..\USB\STM32_USB-FS-Device_Driver\inc;..\USB\CONFIG
  library: MicroLIB
  memory RVCT4: ROM 0x8002400 size 0x1dc00
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CONFIG
    ../CONFIG/interface/: config_param.h
    ../CONFIG/src/: config_param.c
  group TASK
    ../TASK/src/: task_beep.c task_ctrldata.c task_fdbkdata.c task_joystick.c task_key.c task_radio.c
  group GUI_APP
    ../GUI_APP/src/: debug_ui.c display.c joystickCalib_ui.c main_ui.c menu_ui.c menuL1_item.c menuL2_item.c reset_ui.c motof_ui.c motor_ui.c setMaxThrottle_ui.c
    ../GUI_APP/interface/: motof_ui.h motor_ui.h setMaxThrottle_ui.h
  group COMMON
    ../COMMON/src/: debug_assert.c freeRTOSdebug.c
  group HARDWARE
    ../HARDWARE/src/: 24l01.c adc.c key.c led.c oled.c stmflash.c
  group GUI_DRV
    ../GUI_DRV/src/: button.c font.c gui_basic.c gui_menu.c lcmdrv.c messagebox.c scrollbar.c text.c windows.c
    ../GUI_DRV/interface/: gui_config.h
  group FreeRTOS
    ../FreeRTOS/: list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c portmacro.h
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_spi.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_flash.c
  group CORE
    ../CORE/: startup_stm32f10x_md.s
  group README
    ../: README.TXT

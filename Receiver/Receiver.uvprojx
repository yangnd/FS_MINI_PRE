# Keil uVision project Receiver.uvprojx, settings and files
target Receiver (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Receiver +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD
  c include: .\Libraries\CMSIS\CoreSupport;.\Libraries\CMSIS\DeviceSupport;.\Libraries\CMSIS\DeviceSupport\startup;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\FreeRTOS;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM3;.\SYSTEM\inc;.\HARDWARE;.\HARDWARE\inc;.\App;.\Task\inc;.\HARDWARE\LORA
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ./App/: main.c stm32f10x_it.c FreeRTOSConfig.h stm32f10x_conf.h
  group Task
    ./Task/src/: task_key.c task_beep.c task_usart.c task_lora.c
    ./Task/inc/: task_lora.h
  group HARDWARE
    ./HARDWARE/src/: key.c led.c beep.c usart.c
  group SYSTEM
    ./SYSTEM/src/: sys.c delay.c
  group FreeRTOS
    ./FreeRTOS/: list.c queue.c tasks.c timers.c
    ./FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
  group STM32F10x_StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_tim.c
  group CMSIS
    ./Libraries/CMSIS/CoreSupport/: core_cm3.c
    ./Libraries/CMSIS/DeviceSupport/: system_stm32f10x.c
  group Startup Code
    ./Libraries/CMSIS/DeviceSupport/startup/: startup_stm32f10x_hd.s
  group LORA
    ./HARDWARE/LORA/: lora.c timer.c usart3.c
